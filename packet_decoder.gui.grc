options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: packet_decoder
    output_language: python
  states: {}

blocks:
- name: MQTT_PASS
  id: variable_config
  parameters:
    config_file: /home/christian/projects/gnu-heating/credentials.config
    option: MQTT_PASS
    section: main
    type: string
    value: '0'
    writeback: None
  states: {}
- name: MQTT_USER
  id: variable_config
  parameters:
    config_file: /home/christian/projects/gnu-heating/credentials.config
    option: MQTT_USER
    section: main
    type: string
    value: '0'
    writeback: None
  states: {}
- name: center_frequency_0
  id: variable
  parameters:
    value: '140000'
  states: {}
- name: in_frequency
  id: variable
  parameters:
    value: 868.8e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: variable_qtgui_enable_button
  id: variable_qtgui_toggle_button_msg
  parameters:
    gui_hint: '[0,2,1,1]'
    initPressed: 'True'
    label: Run
    pressed: 'True'
    released: 'False'
    type: bool
    value: 'True'
  states: {}
- name: variable_qtgui_sdr_bb_gain_range_0
  id: variable_qtgui_range
  parameters:
    gui_hint: '[4,2,1,1]'
    label: BB Gain (vga)
    start: '0'
    step: '2'
    stop: '60'
    value: '42'
  states: {}
- name: variable_qtgui_sdr_if_gain_range_0
  id: variable_qtgui_range
  parameters:
    gui_hint: '[3,2,1,1]'
    label: IF Gain (lna)
    start: '0'
    step: '8'
    stop: '40'
    value: '24'
  states: {}
- name: variable_qtgui_squelch_threshold_0
  id: variable_qtgui_range
  parameters:
    gui_hint: '[5,2,1,1]'
    label: Squelch threshold
    start: '-100'
    step: '1'
    stop: '-10'
    value: '-44'
  states: {}
- name: variable_qtgui_waterfall_update_interval_multiplier
  id: variable_qtgui_range
  parameters:
    gui_hint: '[2,2,1,1]'
    label: FFT  interval multiplier in 1/10*n
    start: '1'
    step: '0.5'
    stop: '5'
    value: '2'
  states: {}
- name: variable_qtgui_xlating_filter_width_range
  id: variable_qtgui_range
  parameters:
    gui_hint: '[1,2,1,1]'
    label: Filter Width in khz
    start: '0'
    step: '1'
    stop: '500'
    value: '200'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate)/(2*math.pi*50000/8.0)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.005'
    threshold: variable_qtgui_squelch_threshold_0
  states: {}
- name: bitslice_slicer_0
  id: bitslice_slicer
  parameters:
    omega: '5'
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: variable_qtgui_enable_button
    input_index: '0'
    num_inputs: '1'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '00001100011'
    tagname: syncword
    threshold: '0'
    type: byte
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[48,49]'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block demo
      """

      import numpy as np
      from gnuradio import gr
      from datetime import datetime

      import pmt

      from datetime import datetime

      import fileinput
      import json
      cmd_dict = { "0101": "learn", "0000": "off", "1110": "on", "1001": "reset", "1000": "pwm"}


      def calc_checksum(msg):
          s=0
          for pos in range(0, len(msg)-4, 4):
              chunk=int(msg[pos:pos+4][::-1], 2)
              s = (s + chunk)
          return 15 - (s % 15)


      class my_sync_block(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,
                  name = "Heating decoder",
                  in_sig = None,
                  out_sig = None)
              self.message_port_register_in(pmt.intern('msg_in'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)
              
          @staticmethod
          def str_from_msg(msg):
              msg = pmt.to_python(msg)[1]
              msg_str = ''.join(chr(c) for c in msg)
              return msg_str

          def handle_msg(self, msg):	
              msg=my_sync_block.str_from_msg(msg)
              command = msg[12:16]
              command_str = cmd_dict.get(command, "unk")
              adr = msg[0:12]
              seq = int(msg[16:20][::-1], 2)
              chksum = int(msg[20:24][::-1], 2)
              chksumok = "ok" if calc_checksum(msg) == chksum else f"!= {calc_checksum(msg)}"
              print(f"Time: {datetime.now()} Adr: {adr} Cmd: {command} ({command_str}) Seq: {seq} Sum: {chksum} {chksumok}", flush=True)
          
          def work(self, input_items, output_items):
              pass
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: center_frequency_0
    decim: '1'
    samp_rate: samp_rate
    taps: ' firdes.low_pass(1,samp_rate,variable_qtgui_xlating_filter_width_range*1000/(2*1), 10000)'
    type: ccc
  states: {}
- name: manchesterpdu_manchester_pdu_decoder_0
  id: manchesterpdu_manchester_pdu_decoder
  parameters:
    mode: '2'
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52001'
    type: TCP_SERVER
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: variable_qtgui_sdr_bb_gain_range_0
    freq0: in_frequency
    gain0: '0'
    gain_mode0: 'True'
    if_gain0: variable_qtgui_sdr_if_gain_range_0
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: in_frequency+center_frequency_0
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '500'
    srate: samp_rate/160
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '10'
    ymin: '-10'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: in_frequency+center_frequency_0
    fftsize: '1024'
    gui_hint: '[0,0,5,2]'
    type: complex
    update_time: 1/(10**variable_qtgui_waterfall_update_interval_multiplier)
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '160'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: satellites_fixedlen_tagger_0
  id: satellites_fixedlen_tagger
  parameters:
    packet_len: '48'
    packetlen_tag: packet_len
    stream_type: byte
    syncword_tag: syncword
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [bitslice_slicer_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [blocks_selector_0, '0', analog_simple_squelch_cc_0, '0']
- [blocks_selector_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_selector_0, '0', qtgui_waterfall_sink_x_0, '0']
- [digital_binary_slicer_fb_0, '0', bitslice_slicer_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', satellites_fixedlen_tagger_0, '0']
- [digital_map_bb_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_selector_0, '0']
- [manchesterpdu_manchester_pdu_decoder_0, out, epy_block_0, msg_in]
- [manchesterpdu_manchester_pdu_decoder_0, out, network_socket_pdu_0, pdus]
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, manchesterpdu_manchester_pdu_decoder_0, in]
- [rational_resampler_xxx_0, '0', digital_binary_slicer_fb_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [satellites_fixedlen_tagger_0, '0', digital_map_bb_0, '0']

metadata:
  file_format: 1
