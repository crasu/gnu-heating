options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: packet_decoder
    output_language: python
  states: {}

blocks:
- name: MQTT_PASS
  id: variable_config
  parameters:
    config_file: /home/christian/projects/gnu-heating/credentials.config
    option: MQTT_PASS
    section: main
    type: string
    value: '0'
    writeback: None
  states: {}
- name: MQTT_USER
  id: variable_config
  parameters:
    config_file: /home/christian/projects/gnu-heating/credentials.config
    option: MQTT_USER
    section: main
    type: string
    value: '0'
    writeback: None
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '19'
  states: {}
- name: in_frequency
  id: variable
  parameters:
    value: 868.8e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: sample_per_sym
  id: variable
  parameters:
    value: 95/decimation
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate)/(2*math.pi*50000/8.0)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.005'
    threshold: '-50'
  states: {}
- name: bitslice_slicer_0
  id: bitslice_slicer
  parameters:
    omega: '5'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '000011000110'
    tagname: syncword
    threshold: '0'
    type: byte
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[48,49]'
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '115000'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate,samp_rate/(2*1), 55000)
    type: ccc
  states: {}
- name: manchesterpdu_manchester_pdu_decoder_1
  id: manchesterpdu_manchester_pdu_decoder
  parameters: {}
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52001'
    type: TCP_SERVER
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: in_frequency
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decimation
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: satellites_fixedlen_tagger_0
  id: satellites_fixedlen_tagger
  parameters:
    packet_len: '48'
    packetlen_tag: packet_len
    stream_type: byte
    syncword_tag: syncword
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [bitslice_slicer_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', bitslice_slicer_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', satellites_fixedlen_tagger_0, '0']
- [digital_map_bb_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_simple_squelch_cc_0, '0']
- [manchesterpdu_manchester_pdu_decoder_1, out, network_socket_pdu_0, pdus]
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, manchesterpdu_manchester_pdu_decoder_1, in]
- [rational_resampler_xxx_0, '0', digital_binary_slicer_fb_0, '0']
- [satellites_fixedlen_tagger_0, '0', digital_map_bb_0, '0']

metadata:
  file_format: 1
